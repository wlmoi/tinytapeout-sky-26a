VERSION 5.7 ;
NOWIREEXTENSIONATPIN ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;
MACRO tt_um_william_pll
  CLASS BLOCK ;
  FOREIGN tt_um_william_pll ;
  ORIGIN 0.000 0.000 ;
  SIZE 1000.000 BY 1000.000 ;
  OBS
      LAYER M1 ;
        RECT 0.000 0.000 1000.000 1000.000 ;
  END
END tt_um_william_pll
END LIBRARY
